<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>boot_loader</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>72000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\List\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <Books>
        <Book>
          <Number>0</Number>
          <Title>STM32F101 F103 F105 F107 Series Reference Manual</Title>
          <Path>$$Device:STM32F103VC$Documents\STM32F101xx_2xx_3xx_5xx_7xx_UM.pdf</Path>
        </Book>
        <Book>
          <Number>1</Number>
          <Title>STM32F103 Data Sheet</Title>
          <Path>$$Device:STM32F103VC$Documents\STM32F103xC_xD_xE_DS.pdf</Path>
        </Book>
        <Book>
          <Number>2</Number>
          <Title>MCBSTM32E User's Guide</Title>
          <Path>$$Device:STM32F103VC$Documents\mcbstm32e.chm</Path>
        </Book>
        <Book>
          <Number>3</Number>
          <Title>Cortex-M3 Generic User Guide</Title>
          <Path>$$Device:STM32F103VC$Documents\dui0552a_cortex_m3_dgug.pdf</Path>
        </Book>
      </Books>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments> -REMAP</SimDllArguments>
        <SimDlgDllName>DCM.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pCM3</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TCM.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pCM3</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>1</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>BIN\UL2CM3.DLL</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=1190,392,1556,935,0)(1007=105,133,282,394,0)(1008=90,117,456,339,0)(1009=599,175,833,709,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name>(105=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>-UV0168AVR -O206 -S8 -C0 -P00 -N00("ARM CoreSight SW-DP") -D00(1BA01477) -L00(0) -TO18 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO7 -FD20000000 -FC1000 -FN1 -FF0STM32F10x_512.FLM -FS08000000 -FL080000 -FP0($$Device:STM32F103VC$Flash\STM32F10x_512.FLM)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <WatchWindow1>
        <Ww>
          <count>0</count>
          <WinNumber>1</WinNumber>
          <ItemText>g_Invalide_APP_Flag_InBootloader</ItemText>
        </Ww>
      </WatchWindow1>
      <MemoryWindow1>
        <Mm>
          <WinNumber>1</WinNumber>
          <SubType>0</SubType>
          <ItemText>0x40005C3C</ItemText>
        </Mm>
      </MemoryWindow1>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>1</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>STM32F10x_StdPeriph_DriverFWLib3.5</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\Startup\startup_stm32f10x_hd.s</PathWithFileName>
      <FilenameWithoutPath>startup_stm32f10x_hd.s</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\M3\core_cm3.c</PathWithFileName>
      <FilenameWithoutPath>core_cm3.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\misc.c</PathWithFileName>
      <FilenameWithoutPath>misc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_adc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_adc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_bkp.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_bkp.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_can.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_can.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_cec.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_cec.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_crc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_crc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_dac.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_dac.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_dbgmcu.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_dbgmcu.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_dma.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_dma.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_flash.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_flash.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_fsmc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_fsmc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>14</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_gpio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_gpio.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>15</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_i2c.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_i2c.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>16</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_iwdg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_iwdg.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>17</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_pwr.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_pwr.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>18</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_rcc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_rcc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>19</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_rtc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_rtc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>20</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_sdio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_sdio.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>21</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_spi.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_spi.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>22</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_tim.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_tim.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>23</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_usart.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_usart.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>24</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB\stm32f10x_wwdg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_wwdg.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>25</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\M3\system_stm32f10x.c</PathWithFileName>
      <FilenameWithoutPath>system_stm32f10x.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>26</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137203360</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\M3\stm32f10x_it.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_it.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>STM32_USB-FS-Device_Driver</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>27</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137576432</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32_USB-FS-Device_Driver\src\otgd_fs_cal.c</PathWithFileName>
      <FilenameWithoutPath>otgd_fs_cal.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>28</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137576432</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32_USB-FS-Device_Driver\src\otgd_fs_dev.c</PathWithFileName>
      <FilenameWithoutPath>otgd_fs_dev.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>29</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137576432</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32_USB-FS-Device_Driver\src\otgd_fs_int.c</PathWithFileName>
      <FilenameWithoutPath>otgd_fs_int.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>30</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137576432</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32_USB-FS-Device_Driver\src\otgd_fs_pcd.c</PathWithFileName>
      <FilenameWithoutPath>otgd_fs_pcd.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>31</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137576432</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32_USB-FS-Device_Driver\src\usb_core.c</PathWithFileName>
      <FilenameWithoutPath>usb_core.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>32</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137576432</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32_USB-FS-Device_Driver\src\usb_init.c</PathWithFileName>
      <FilenameWithoutPath>usb_init.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>33</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137576432</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32_USB-FS-Device_Driver\src\usb_int.c</PathWithFileName>
      <FilenameWithoutPath>usb_int.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>34</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137576432</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32_USB-FS-Device_Driver\src\usb_mem.c</PathWithFileName>
      <FilenameWithoutPath>usb_mem.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>35</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137576432</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32_USB-FS-Device_Driver\src\usb_regs.c</PathWithFileName>
      <FilenameWithoutPath>usb_regs.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>36</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137576432</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Libraries\STM32_USB-FS-Device_Driver\src\usb_sil.c</PathWithFileName>
      <FilenameWithoutPath>usb_sil.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>USB</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>37</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137611176</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\USB\usb_cfg.c</PathWithFileName>
      <FilenameWithoutPath>usb_cfg.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>38</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137611176</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\USB\usb_desc.c</PathWithFileName>
      <FilenameWithoutPath>usb_desc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>39</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137611176</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\USB\usb_endp.c</PathWithFileName>
      <FilenameWithoutPath>usb_endp.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>40</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137611176</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\USB\usb_istr.c</PathWithFileName>
      <FilenameWithoutPath>usb_istr.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>41</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137611176</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\USB\usb_prop.c</PathWithFileName>
      <FilenameWithoutPath>usb_prop.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>42</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137611176</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\USB\usb_pwr.c</PathWithFileName>
      <FilenameWithoutPath>usb_pwr.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>43</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137611176</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\USB\usb_cfg.h</PathWithFileName>
      <FilenameWithoutPath>usb_cfg.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>44</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137611176</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\USB\usb_conf.h</PathWithFileName>
      <FilenameWithoutPath>usb_conf.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>45</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137611176</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\USB\usb_desc.h</PathWithFileName>
      <FilenameWithoutPath>usb_desc.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>46</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137611176</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\USB\usb_istr.h</PathWithFileName>
      <FilenameWithoutPath>usb_istr.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>47</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137611176</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\USB\usb_prop.h</PathWithFileName>
      <FilenameWithoutPath>usb_prop.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>48</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137611176</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\USB\usb_pwr.h</PathWithFileName>
      <FilenameWithoutPath>usb_pwr.h</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>sys</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>49</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137651680</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\sys\system.c</PathWithFileName>
      <FilenameWithoutPath>system.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>50</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137651680</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\sys\main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>51</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137651680</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\sys\evb_flash.c</PathWithFileName>
      <FilenameWithoutPath>evb_flash.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>52</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137651680</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\sys\Bootloader.c</PathWithFileName>
      <FilenameWithoutPath>Bootloader.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>53</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137651680</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\sys\common.c</PathWithFileName>
      <FilenameWithoutPath>common.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>54</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137651680</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\sys\task_process.c</PathWithFileName>
      <FilenameWithoutPath>task_process.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>periph</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>55</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137672768</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\periph\gpio_defs.h</PathWithFileName>
      <FilenameWithoutPath>gpio_defs.h</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>services</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>56</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137679800</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\services\server_comm_protocol.c</PathWithFileName>
      <FilenameWithoutPath>server_comm_protocol.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>57</FileNumber>
      <FileType>1</FileType>
      <tvExp>1</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137679800</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\services\server_comm_controller.c</PathWithFileName>
      <FilenameWithoutPath>server_comm_controller.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>58</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>137679800</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>23982156</TopLine>
      <CurrentLine>1709028</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\USER\services\time_server.c</PathWithFileName>
      <FilenameWithoutPath>time_server.c</FilenameWithoutPath>
    </File>
  </Group>

</ProjectOpt>
